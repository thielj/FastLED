# IAR project FastLED_STM8_IAR.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x200
  ICCSTM8.CCIncludePath2: ..\..\..
  ICCSTM8.IccLang: 2
  OBJCOPY.OOCOutputFile: FastLED_STM8_IAR.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenStackSize: 0x050
  General.GenHeapSize: 0x050
  ICCSTM8.CCDefines: NDEBUG=1; MCU=STM8S103F3; F_CPU=16000000; _MCU_H=<iostm8s103f3.h>
  ICCSTM8.CCDiagSuppress: Pe940
  ICCSTM8.IccLang: 1
  ASTM8.AsmIncludePath: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: FastLED_STM8_IAR.hex
  ILINK.IlinkOutputFile: FastLED_STM8_IAR.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8s103f3.icf
configuration Simulator (STM8, debug)
  as the first configuration, except:
  General.GenStackSize: 0x100
  ICCSTM8.CCDefines: _STM8_SIMULATOR_; MCU=STM8S103F3
  ICCSTM8.CCDiagSuppress: Pa137,Pe001,Pe193,Pe237,Pe38,Pe826,Pe940
  ICCSTM8.IccExtraOptions: --ludicrous_speed
  ICCSTM8.IccLang: 1
  group (top)
    ../../../: bitswap.cpp bitswap.h chipsets.h color.h colorpalettes.cpp colorpalettes.h colorutils.cpp colorutils.h controller.h cpp_compat.h dmx.h FastLED.cpp FastLED.h fastled_config.h fastled_delay.h fastled_progmem.h fastpin.h fastspi.h fastspi_bitbang.h fastspi_dma.h fastspi_ref.h fastspi_types.h hsv2rgb.cpp hsv2rgb.h led_sysdefs.h lib8tion.cpp lib8tion.h main.cpp noise.cpp noise.h pixelset.h pixeltypes.h platforms.h
  group lib8tion
    ../../../lib8tion/: math8.h random8.h scale8.h trig8.h
  group platforms/stm8
    ../: clockless_stm8.h color_stm8.cpp color_stm8.h fastled_stm8.h led_sysdefs_stm8.h lib_stm8.cpp lib_stm8.h
  group platforms/stm8/hal
    ../hal/: compat.h crc.c crc.h debug.h delay.c delay.h delay_cycles_fixed.asm delay_cycles_variable.asm math.c math.h math.txt misc.h pin.h random.c random.h stm8hal.c stm8hal.h timer.c timer.h
  group platforms/stm8/hal/variants
    ../hal/variants/: STM8S001J3.h STM8S003F3.h STM8S003K3.h STM8S005K6.h STM8S103F2.h STM8S103F3.h STM8S103K3.h STM8S105K4.h STM8S105K6.h STM8Sx03F.h STM8Sx03K.h STM8Sx05K.h
