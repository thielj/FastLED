<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\FastLED_STM8_IAR.ewp</path>
    </project>
    <batchBuild />
</workspace>
